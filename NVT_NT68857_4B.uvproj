# Keil uVision project NVT_NT68857_4B.uvproj, settings and files
target NT68857_MODULE_1080 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT68857_MODULE_1080 +hex
  AfterMake: bank_chk.exe NVT_NT68857_4B_MISC.lin NVT_NT68857_4B.UV2
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_MODULE,NVT_1920X1080,FLASH_BANK=4
  c include: .\App;.\App\OSD;.\App\User;.\Lib;.\Lib\NT68655_770_850 Series;.\Lib\ScalerCfg;.\Phy\Panel;.\Phy\SI\NVT\Board;.\Phy\SI\NVT\Component;.\Phy\SI\NVT\Keypad;.\Sys;.\Sys\SI\NVT;.\Phy\SI\NVT\Keypad\NT68857_MODULE_KEYPAD
  link misc: B0(?CO?MODETABLE,?CO?SCALER_COMMON,?CO?HDCPAPI)
B1(?CO?OSDFONT,?CO?OSDINDEX,?CO?OSDFUNC,?CO?FOSDVIEW)
B2(?CO?GAMMA,?CO?COLORCONFIG,?CO?LOGO, ?CO?OD,?CO?DBC)
B3(?CO?DDCCI, ?CO?LD, ?CO?MHL,?CO?SCALER_DP)
  group Common
    ./Lib/: Int.c NT68F631_4bank.a51 ScalerAccess.c OSDAPI_Common.c STARTUP_A000.A51 fe2p_large_3.13.LIB
    ./Sys/: Main.c EmbedCheckSum.c
    ./Lib/NT68655_770_850 Series/: Scaler_DP_Common.c
    ./App/: ChiuDef.h
    ./: ReadMe.txt
  group Bank0
    ./Lib/: AutoAdj.c Mcu.c McuADC.c McuDDC.c McuIO.c McuPWM.c McuHwIIC.c
    ./Sys/: AutoAdjConfig.c SyncHandler.c ModeHandler.c ModeTable.c ModeSearch.c ModeConfig.c NR.c Nvram.c NvramIIC.c SysAPI.c Misc.c Ram.c
    ./Phy/SI/NVT/Board/: Board.c
    ./App/: HDCP.c
    ./Phy/Panel/: Panel.c
    ./Lib/NT68655_770_850 Series/: Scaler_CSC.c ScalerReg.c Scaler_3D.c Scaler_ADC.c Scaler_Capture.c Scaler_Common.c Scaler_Display.c Scaler_Dithering.c Scaler_HDMI.c Scaler_LedDriver.c Scaler_LVDS.c Scaler_MMU.c Scaler_NR.c Scaler_Power.c Scaler_PWM.c Scaler_Sync.c Scaler_TMDS.c Fe2p_API.c HDCPAPI.c McuReg.c Scaler_MHL.c
  group Bank1
    ./App/OSD/: OSDAPI_Indent.c OSDFont.c OSDFunc.c OSDIndex.c OSDView.c FOSDView.c OSDCtrl.c
    ./Lib/NT68655_770_850 Series/: OSDAPI.c
  group Bank2
    ./App/: APPCtrl.c EventHandle.c KeyCtrl.c ColorConfig.c Gamma.c OD.c DBC.c 3D.c CM3218_ALSMode.c CM3218_ALSOffset.c LS3101_ADS.c XRS232_APP.c XRS232_LWO_APP.c
    ./App/User/: UserSetting.c
    ./Lib/: ColorEngine_Large.LIB GammaAPI.c ODTransform_Large.LIB ODAPI.c
    ./App/OSD/: Logo.c DemoOSDView.c
    ./Lib/NT68655_770_850 Series/: DBCAPI.c
    ./Phy/SI/NVT/Keypad/: KeyPad.c IR.c
  group Bank3
    ./Lib/: CEC.c
    ./App/: Ddcci.c DdcciCtrl.c LD.c SR.c MHL.c
    ./Lib/NT68655_770_850 Series/: SRAPI.c LDAPI.c Scaler_DP.c
target NT68857_DEMO_1080 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT856_AU_12280x1024_150817 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X17N
  c include: .\App;.\App\OSD;.\App\User;.\Lib;.\Lib\NT68655_770_850 Series;.\Lib\ScalerCfg;.\Phy\Panel;.\Phy\SI\NVT\Board;.\Phy\SI\NVT\Component;.\Phy\SI\NVT\Keypad;.\Sys;.\Sys\SI\NVT
  link misc: as above
target NT68857_FPGA_1080 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT68857_FPGA_1080 +hex
  AfterMake: bank_chk.exe NVT_NT68857_4B_MISC.lin NVT_NT68857_4B.UV2
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_MODULE,NVT_1920X1080,ENABLE_FPGA_MODE,FLASH_BANK=4
  c include: as above
  link misc: as above
target NT68857_MODULE_1050 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT68857_MODULE_1050 +hex
  AfterMake: bank_chk.exe NVT_NT68857_4B_MISC.lin NVT_NT68857_4B.UV2
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_MODULE,NVT_1680X1050,FLASH_BANK=4
  c include: as above
  link misc: as above
target NT68857_SRP_640x480 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT856_SRP_6400x480_150907T +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X06N
  c include: as above
  link misc: as above
target NT856_TRULY_TFT1280120-1-E (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT856_AD908_ONation_TRULY_TFT1280120-1-E_151013 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,SPECIAL_TRULY_TFT1280120
  c include: as above
  link misc: as above
target ADS-AD07_GDS_AUO_P460HVN03.0 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: ADS-AD907_GDS_AUO_P460HVN03.0_1920x1080_150930 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X46W
  c include: as above
  link misc: as above
target ADS-AD908_15"_XGA (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT856_SYSCON_IVO_1024x768_160114 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X15N
  c include: as above
  link misc: as above
target IBER-LWO_NT856_INL_S290AJ1-LE1 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: IBER-LWO_NT856_INL_S290AJ1-LE1_1920x540_151126 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X29CutW
  c include: as above
  link misc: as above
target AD908_46"_JEIDA(10-8bit) (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT856_Nextech_X46W_1920x1080_151210 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X46W
  c include: as above
  link misc: as above
target AXI_AX98310_G104X1-L04 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT856_CMO_AXI_G104X1-L04_1024X768_151222 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X10N
  c include: as above
  link misc: as above
target AD908_SGD_GVTW70SNAD1E0 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT856_SGD_GVTW70SNAD1E0_800X480_160106 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X07W
  c include: as above
  link misc: as above
target AD908_IBER-LWO_T215HVN01.1 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT856_IBHM-LWO_AUO_T215HVN01.1_1920x1080_160119 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X215
  c include: as above
  link misc: as above
target AD908_GDS_P550HVN01_V2 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: AD908_GDS_AUO_P550HVN01.2_1920x1080_160120 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X46W
  c include: as above
  link misc: as above
target AD908_Nextech_21.5_AutoDim+Remote (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT856_AD908_Nextech_215_1080p_ALS+IR-Remte_160222 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X215
  c include: as above
  link misc: as above
target AD908_LWO_19W_RS232 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT856_AD908_X17N_160304T +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X17N
  c include: as above
  link misc: as above
target AD907_X15N_Test (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT856_AD908_X15N_160308T +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X10W
  c include: as above
  link misc: as above
target LWO-AD908_AXI_X10W (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: AXI_LWOAD908_X10W_160309 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X10W
  c include: as above
  link misc: as above
target NT856_AD908-LWO_21.5 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT856_AD908-LWO_X215_160318 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X215
  c include: as above
  link misc: as above
target NT856_IVO_1024x768 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: AXI_AX98312_X15N__SAAB_1024x768_181126 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68857,NT68857_DEMO,FLASH_BANK=4,X15N
  c include: as above
  link misc: as above
